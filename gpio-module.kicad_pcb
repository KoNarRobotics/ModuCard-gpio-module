# Repository KoNarRobotics/ModuCard-gpio-module (continued)

## KiCad design gpio-module.kicad_pcb (continued)

Parts:
C700: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
C701, C702, C703, C704, C705, C706: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C707, C708: 33pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG330J500NT; LCSC C1562
D700, D701: Red; D_0603; Part KT-0603R; LCSC C2286
Q700: MMST3904; Q_SOT-323; Part MMST3904; LCSC C22388837
R700, R702: 100kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1003TCE; LCSC C25741
R701, R703, R705, R707, R709, R713: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R704, R708, R715, R716: 22Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF220JTCE; LCSC C25092
R706: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744; not fitted
R710, R714: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076
R711: 39kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF3902TCE; LCSC C25783
R712: 1.5kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1501TCE; LCSC C25867
TP700, TP701, TP702, TP703, TP704, TP705, TP706: TestPoint; TestPoint_Pad_D1.0mm
U700: STM32F103CBTx; LQFP-48_7x7mm_P0.5mm
Y700: 8 MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL; MPN 3225-8.00-20-10-10/4B; LCSC C7424755

Connections:
+3V3: C700.1, C701.1, C702.1, C703.1, C704.1, C705.1, Q700.3 (C), R700.1, R701.1, R707.1, TP702.1, U700.1 (VBAT), U700.9 (VDDA), U700.24 (VDD), U700.36 (VDD), U700.48 (VDD); also elsewhere on the board
+5V: R709.1; also elsewhere on the board
/MCU/SWD.SWCLK: R704.2, R715.1; also elsewhere on the board
/MCU/SWD.SWDIO: R716.1; also elsewhere on the board
/MCU/SWD.~RST: R708.1; also elsewhere on the board
/ST-LINK/CLK: TP705.1, U700.37 (PA14)
/ST-LINK/DIO: TP704.1, U700.34 (PA13)
/ST-LINK/LED: D700.1, D701.2, U700.30 (PA9)
/ST-LINK/ST-LINK.D+: R712.2, U700.33 (PA12); also elsewhere on the board
/ST-LINK/ST-LINK.D-: U700.32 (PA11); also elsewhere on the board
/ST-LINK/STLINK-BOOT0: R702.2, TP703.1, U700.44 (BOOT0)
/ST-LINK/STLINK-OSC_IN: C707.1, U700.5 (PD0), Y700.1
/ST-LINK/STLINK-OSC_OUT: C708.1, U700.6 (PD1), Y700.3
/ST-LINK/STLINK-RST: C706.1, R700.2, U700.7 (NRST)
/ST-LINK/STLINK_RX: TP701.1, U700.13 (PA3)
/ST-LINK/STLINK_TX: TP700.1, U700.12 (PA2)
/ST-LINK/SWO: U700.31 (PA10)
/ST-LINK/USB_RENUM: R710.2, U700.38 (PA15)
GND: C700.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, R702.1, R703.2, R705.1, R706.1, R711.2, R713.2, TP706.1, U700.8 (VSSA), U700.23 (VSS), U700.35 (VSS), U700.47 (VSS), Y700.2, Y700.4; also elsewhere on the board
unnamed: D700.2, R707.2
unnamed: D701.1, R713.1
unnamed: Q700.1 (B), R709.2, R710.1, R711.1
unnamed: Q700.2 (E), R712.1
unnamed: R701.2, R703.1, U700.10 (PA0)
unnamed: R704.1, U700.15 (PA5)
unnamed: R708.2, U700.18 (PB0)
unnamed: R714.2, U700.25 (PB12)
unnamed: R715.2, U700.26 (PB13)
unnamed: R714.1, R716.2, U700.27 (PB14)
unnamed: R705.2, U700.2 (PC13)
unnamed: R706.2, U700.3 (PC14)

Notes on the sheet:
Alternative GD32F103CB
SWD
NOTICE:
C707=C708 = (CL - 4pF) * 2
Monitor voltage rail 3V3 instead of target MCU voltage
https://stm32world.com/wiki/DIY_STM32_Programmer_(ST-Link/V2-1)
CAUTION:
Populate with STM32F103C8, STM32F103CB
ACTIVITY LED
for providing amazing reverse engeenering of ST-link
MANDATORY CB VERSION
FORCE RENUMERATION OF USB DEVICES
https://github.com/lbthomsen/st-link/tree/master
Credit to:

Schematic: backplane.kicad_sch, ModuCard GPIO module

Parts:
J200: 09031967921; DIN41612_R_3x32_Female_Horizontal_THT; PARTREV D
U402: TPD2E2U06DCK; SOT-323_SC-70

Connections:
+5V_STDBY: J200.a3, J200.b3, J200.c3
+12V: J200.a11, J200.a12, J200.b11, J200.b12, J200.c11, J200.c12; also elsewhere on the board
+24V: J200.a14, J200.b14, J200.c14
/Backplane/BACKPLANE.D+: J200.a2, U402.2; also elsewhere on the board
/Backplane/BACKPLANE.D-: J200.c2, U402.1; also elsewhere on the board
/Backplane/CAN1.+: J200.a5, J200.b5, J200.c5; also elsewhere on the board
/Backplane/CAN1.-: J200.a6, J200.b6, J200.c6; also elsewhere on the board
/Backplane/CAN2.+: J200.a8, J200.b8, J200.c8; also elsewhere on the board
/Backplane/CAN2.-: J200.a9, J200.b9, J200.c9; also elsewhere on the board
/Backplane/GPIOC0: J200.b16
/Backplane/GPIOC1: J200.b17
/Backplane/GPIOC2: J200.b18
/Backplane/GPIOC3: J200.b19
/Backplane/GPIOC4: J200.b20
/Backplane/GPIOC5: J200.b21
/Backplane/GPIOC6: J200.b22
/Backplane/GPIOC7: J200.b23
/Backplane/GPIOC8: J200.b24
/Backplane/GPIOC9: J200.b25
/Backplane/GPIOC10: J200.b26
/Backplane/GPIOC11: J200.b27
/Backplane/GPIOC12: J200.b28
/Backplane/GPIOC13: J200.b29
/Backplane/GPIOC14: J200.b30
/Backplane/GPIOC15: J200.b31
/Backplane/GPIOL0: J200.a16; also elsewhere on the board
/Backplane/GPIOL1: J200.a17; also elsewhere on the board
/Backplane/GPIOL2: J200.a18; also elsewhere on the board
/Backplane/GPIOL3: J200.a19; also elsewhere on the board
/Backplane/GPIOL4: J200.a20; also elsewhere on the board
/Backplane/GPIOL5: J200.a21; also elsewhere on the board
/Backplane/GPIOL6: J200.a22; also elsewhere on the board
/Backplane/GPIOL7: J200.a23; also elsewhere on the board
/Backplane/GPIOL8: J200.a24; also elsewhere on the board
/Backplane/GPIOL9: J200.a25; also elsewhere on the board
/Backplane/GPIOL10: J200.a26; also elsewhere on the board
/Backplane/GPIOL11: J200.a27; also elsewhere on the board
/Backplane/GPIOL12: J200.a28; also elsewhere on the board
/Backplane/GPIOL13: J200.a29; also elsewhere on the board
/Backplane/GPIOL14: J200.a30; also elsewhere on the board
/Backplane/GPIOL15: J200.a31; also elsewhere on the board
/Backplane/GPIOR0: J200.c16; also elsewhere on the board
/Backplane/GPIOR1: J200.c17; also elsewhere on the board
/Backplane/GPIOR2: J200.c18; also elsewhere on the board
/Backplane/GPIOR3: J200.c19; also elsewhere on the board
/Backplane/GPIOR4: J200.c20; also elsewhere on the board
/Backplane/GPIOR5: J200.c21; also elsewhere on the board
/Backplane/GPIOR6: J200.c22; also elsewhere on the board
/Backplane/GPIOR7: J200.c23; also elsewhere on the board
/Backplane/GPIOR8: J200.c24; also elsewhere on the board
/Backplane/GPIOR9: J200.c25; also elsewhere on the board
/Backplane/GPIOR10: J200.c26; also elsewhere on the board
/Backplane/GPIOR11: J200.c27; also elsewhere on the board
/Backplane/GPIOR12: J200.c28; also elsewhere on the board
/Backplane/GPIOR13: J200.c29; also elsewhere on the board
/Backplane/GPIOR14: J200.c30; also elsewhere on the board
/Backplane/GPIOR15: J200.c31; also elsewhere on the board
GND: J200.a1, J200.a4, J200.a7, J200.a10, J200.a13, J200.a15, J200.a32, J200.b1, J200.b2, J200.b4, J200.b7, J200.b10, J200.b13, J200.b15, J200.b32, J200.c1, J200.c4, J200.c7, J200.c10, J200.c13, J200.c15, J200.c32, U402.3; also elsewhere on the board

Notes on the sheet:
USB
CAN
POWER FLAGS
USB

Schematic: mosfet-power-stage.kicad_sch, ModuCard GPIO module

Parts:
Q405: AO3400A; Q_SOT-23; Part AO3400A; LCSC C20917
R423: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R426: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076

Connections:
/GPIO connector 0/MOSFET power stage/output: Q405.3 (D); also elsewhere on the board
/GPIO connector 0/output: R423.1, R426.1; also elsewhere on the board
GND: Q405.2 (S), R423.2; also elsewhere on the board
unnamed: Q405.1 (G), R426.2

Parts of its further copies:
Q406, Q407, Q408: AO3400A; Q_SOT-23; Part AO3400A; LCSC C20917
R425, R429, R436: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R427, R430, R437: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076

Connections of its further copies:
/GPIO connector 1/MOSFET power stage/output: Q406.3 (D); also elsewhere on the board
/GPIO connector 1/output: R425.1, R427.1; also elsewhere on the board
/GPIO connector 2/MOSFET power stage/output: Q407.3 (D); also elsewhere on the board
/GPIO connector 2/output: R429.1, R430.1; also elsewhere on the board
/GPIO connector 3/MOSFET power stage/output: Q408.3 (D); also elsewhere on the board
/GPIO connector 3/output: R436.1, R437.1; also elsewhere on the board
GND: Q406.2 (S), Q407.2 (S), Q408.2 (S), R425.2, R429.2, R436.2; also elsewhere on the board
unnamed: Q406.1 (G), R427.2
unnamed: Q407.1 (G), R430.2
unnamed: Q408.1 (G), R437.2

Board: 4 copper layers, 100.0 x 100.0 mm, 190 parts (11 on the bottom side), 155 nets.

Other parts of the board:
kibuzzard-67B20BD5: G***; kibuzzard-67B20BD5
kibuzzard-67B63E8D: G***; kibuzzard-67B63E8D
kibuzzard-67B219C6: G***; kibuzzard-67B219C6
kibuzzard-67B624A4: G***; kibuzzard-67B624A4
kibuzzard-67B643AC: G***; kibuzzard-67B643AC
kibuzzard-67B643DE: G***; kibuzzard-67B643DE
kibuzzard-67B643EE: G***; kibuzzard-67B643EE
kibuzzard-67B2198C: G***; kibuzzard-67B2198C
kibuzzard-67B6248A: G***; kibuzzard-67B6248A
kibuzzard-67B6249A: G***; kibuzzard-67B6249A
kibuzzard-67B6438D: G***; kibuzzard-67B6438D
kibuzzard-67B37005: G***; kibuzzard-67B37005
kibuzzard-67B37418: G***; kibuzzard-67B37418
kibuzzard-67B37472: G***; kibuzzard-67B37472
kibuzzard-67B62451: G***; kibuzzard-67B62451
kibuzzard-67B62470: G***; kibuzzard-67B62470
kibuzzard-67BE3F52: G***; kibuzzard-67BE3F52
kibuzzard-67E7D86B: G***; kibuzzard-67E7D86B
kibuzzard-682A47D8: G***; kibuzzard-682A47D8

## Commit log

2025-04-19 [#1] Init project using the template - base module project
2025-04-19 [#1] Use Kicad 9 in CI
2025-04-19 [#1] Activate CI on pull request
2025-04-19 Add generated schematic PDF and Gerber files
2025-04-19 [#1] Init project from base-module template
2025-04-19 [#1] Add LED connector and GPIO connectors, place connectors on PCB
2025-04-19 [#1] Connect LED connector to MCU
2025-04-20 [#1] Connect all GPIO connectors to MCU
2025-04-20 [#1] Connect GPIOR to MCU
2025-05-18 [#1] Connect 12V to front connectors, connect GPIOL to MCU
2025-05-18 [#1] Improve GPIO tracks spacing
2025-05-18 [#1] Connect power to the RGB LED connector, minor tracks corrections
2025-05-18 [#1] Add connectors descriptions on silkscreen
2025-05-18 [#1] Clear ERC and DRC
2025-05-19 [#1] Add voltage divider to GPIO input
2025-05-19 [#1] Clear ERC
2025-05-25 change RGB to CH3 and change pinout
2025-05-25 fix git sync issue
2025-05-27 Replace RGB with CH3 and adjust silk
2025-05-28 Remove base-module gerber files
2025-05-28 [#8] Fix missing component values, fix soldermask expansion of U800 and remove its designator from silkscreen, minor schematic fixes
2025-06-19 [#8] Fix LEDs resistors values
2025-06-19 [#8] Bump project to rev.1.1.1
2025-06-19 [#1] Fill out schematic title block, connect GPIOs on the schematic
2025-06-19 [#1] Finish PCB
2025-06-19 [#6] Define ADC pins, start rerouting
2025-06-19 [#6] WIP: connect GPIO
