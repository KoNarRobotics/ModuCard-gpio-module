# Repository KoNarRobotics/ModuCard-gpio-module

## KiCad design gpio-module.kicad_pcb

Parts:
C500, C501: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
R500: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
U500: TJA1044GTK_3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm; Manufacturer_Part_Number TJA1044GTK/3Z

Connections:
+3V3: C501.1, U500.5 (VIO); also elsewhere on the board
+5V: C500.2, U500.3 (VCC); also elsewhere on the board
/Backplane/CAN1.+: U500.7 (CANH); also elsewhere on the board
/Backplane/CAN1.-: U500.6 (CANL); also elsewhere on the board
/CAN transceiver 1/CAN.RX: U500.4 (RXD); also elsewhere on the board
/CAN transceiver 1/CAN.TX: U500.1 (TXD); also elsewhere on the board
GND: C500.1, C501.2, R500.2, U500.2 (GND), U500.9 (EP); also elsewhere on the board
unnamed: R500.1, U500.8 (STB)

Parts of its further copies:
C600, C601: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
R600: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
U600: TJA1044GTK_3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm; Manufacturer_Part_Number TJA1044GTK/3Z

Connections of its further copies:
+3V3: C601.1, U600.5 (VIO); also elsewhere on the board
+5V: C600.2, U600.3 (VCC); also elsewhere on the board
/Backplane/CAN2.+: U600.7 (CANH); also elsewhere on the board
/Backplane/CAN2.-: U600.6 (CANL); also elsewhere on the board
/CAN transceiver 2/CAN.RX: U600.4 (RXD); also elsewhere on the board
/CAN transceiver 2/CAN.TX: U600.1 (TXD); also elsewhere on the board
GND: C600.1, C601.2, R600.2, U600.2 (GND), U600.9 (EP); also elsewhere on the board
unnamed: R600.1, U600.8 (STB)

Notes on the sheet:
CAN TRANSCEIVER

Parts:
J9: Molex_Micro-Fit_3.0 2x2; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal; MPN 43045-0400
R400: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R420: 22kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2202TCE; LCSC C25768

Connections:
+5V: J9.4; also elsewhere on the board
+12V_GPIO: J9.1; also elsewhere on the board
/GPIO connector 0/MOSFET power stage/output: J9.2; also elsewhere on the board
/GPIO connector 0/input: R400.2, R420.1; also elsewhere on the board
GND: R420.2; also elsewhere on the board
unnamed: J9.3, R400.1

Parts of its further copies:
J8, J10, J11: Molex_Micro-Fit_3.0 2x2; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal; MPN 43045-0400
R417, R418, R419: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R421, R422, R424: 22kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2202TCE; LCSC C25768

Connections of its further copies:
+5V: J8.4, J10.4, J11.4; also elsewhere on the board
+12V_GPIO: J8.1, J10.1, J11.1; also elsewhere on the board
/GPIO connector 1/MOSFET power stage/output: J10.2; also elsewhere on the board
/GPIO connector 1/input: R417.2, R421.1; also elsewhere on the board
/GPIO connector 2/MOSFET power stage/output: J11.2; also elsewhere on the board
/GPIO connector 2/input: R418.2, R422.1; also elsewhere on the board
/GPIO connector 3/MOSFET power stage/output: J8.2; also elsewhere on the board
/GPIO connector 3/input: R419.2, R424.1; also elsewhere on the board
GND: R421.2, R422.2, R424.2; also elsewhere on the board
unnamed: J8.3, R419.1
unnamed: J10.3, R417.1
unnamed: J11.3, R418.1

Notes on the sheet:
Increase resistance of this resistor, to extend the voltage range of the input

Parts:
C300, C305, C306, C311: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C301, C302, C303, C304, C309, C310: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
C307, C308: 22uF; C_0603; Voltage Rated 6.3V; Tolerance ±20%; Part CL10A226MQ8NRNC; LCSC C59461
D400, D401, D402: Red; D_0603; Part KT-0603R; LCSC C2286
F300: 1.5A; F_0603; Part F06F1.5; LCSC C2924957
F301: Fuse; R_0603
JP300, JP301: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L300, L301: 3.3uH; L_Changjiang_FXL0420
R300: 54k9; R_0402
R301, R307: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R306: 33k2; R_0402
R410: 2.2kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2201TCE; LCSC C25879
R411: 470Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF4700TCE; LCSC C25117
R412: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
TP300, TP301, TP302, TP303, TP400: TestPoint; TestPoint_Pad_D1.0mm
U300, U301: TPS563200; SOT-23-6

Connections:
+3V3: D402.2, JP301.2 (B), TP302.1; also elsewhere on the board
+5V: D401.2, JP300.2 (B), TP301.1; also elsewhere on the board
+12V: F300.1, F301.1; also elsewhere on the board
+12V_FUSED: C303.1, C304.1, C305.2, C309.1, C310.1, C311.2, D400.2, F300.2, TP300.1, U300.3 (VIN), U300.5 (EN), U301.3 (VIN), U301.5 (EN)
+12V_GPIO: F301.2, TP303.1; also elsewhere on the board
/Power/+3V3_UNPROTEC: C307.1, C308.1, JP301.1 (A), L301.2, R306.1
/Power/+5V_UNPROTEC: C301.1, C302.1, JP300.1 (A), L300.2, R300.1
/Power/FB_3V3: R306.2, R307.1, U301.4 (VFB)
/Power/FB_5V0: R300.2, R301.1, U300.4 (VFB)
/Power/SW_3V3: C306.2, L301.1, U301.2 (SW)
/Power/SW_5V0: C300.2, L300.1, U300.2 (SW)
/Power/VBST_3V3: C306.1, U301.6 (VBST)
/Power/VBST_5V0: C300.1, U300.6 (VBST)
GND: C301.2, C302.2, C303.2, C304.2, C305.1, C307.2, C308.2, C309.2, C310.2, C311.1, R301.2, R307.2, R410.2, R411.2, R412.2, TP400.1, U300.1 (GND), U301.1 (GND); also elsewhere on the board
unnamed: D400.1, R410.1
unnamed: D401.1, R411.1
unnamed: D402.1, R412.1

Notes on the sheet:
V_{OUT} = 0.765*(1+33k2/10k) = 3.3V
Max expected current = 1.2A
V_{OUT} = 0.765*(1+R302/R307)
Target I_{LED} = 5mA
V_{OUT} = 0.765*(1+R300/R301)
5V DC/DC CONVERTER
V_{OUT} = 0.765*(1+54k9/10k) = 4.96V
POWER INDICATOR LEDs
3V3 DC/DC CONVERTER

Parts:
C312, C800, C801: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
J800: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R800, R801: 5.1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF5101TCE; LCSC C25905
R802, R804: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R803: 22kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2202TCE; LCSC C25768
R805: 330Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF3300TCE; LCSC C25104
U401: TPD2E2U06DCK; SOT-323_SC-70
U801: FSUSB42UMX; UFQFN-10_1.4x1.8; PARTREV 1.25

Connections:
+3V3: C312.1, U801.9 (VCC); also elsewhere on the board
/Backplane/BACKPLANE.D+: U801.5 (HSD1+); also elsewhere on the board
/Backplane/BACKPLANE.D-: U801.4 (HSD1-); also elsewhere on the board
/USB-hub/USBIN1.D+: U801.1 (D+); also elsewhere on the board
/USB-hub/USBIN1.D-: U801.2 (D-); also elsewhere on the board
/USB/CC1: J800.A5 (CC1), R801.1
/USB/CC2: J800.B5 (CC2), R800.1
/USB/USB2S.D+: J800.A6 (D+), J800.B6 (D+), U401.1, U801.7 (HSD2+)
/USB/USB2S.D-: J800.A7 (D-), J800.B7 (D-), U401.2, U801.6 (HSD2-)
/USB/VBUS_IN: C800.1, J800.A4 (VBUS), J800.A9 (VBUS), J800.B4 (VBUS), J800.B9 (VBUS), R802.1
GND: C312.2, C800.2, C801.2, J800.A1 (GND), J800.A12 (GND), J800.B1 (GND), J800.B12 (GND), R800.2, R801.2, R803.2, R804.2, R805.2, U401.3, U801.3 (GND); also elsewhere on the board
unnamed: C801.1, J800.S1 (SHIELD), R805.1
unnamed: R802.2, R803.1, U801.10 (SEL)
unnamed: R804.1, U801.8 (~OE)

Parts:
BTN400: TL2243
C313, C314: 18pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG180J500NT; LCSC C1549
C400, C403, C423, C425: 10uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A106MQ5NUNC; LCSC C15525
C401, C402, C404, C405, C406, C415, C416, C420, C421, C422, C424, C426, C432: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C410: 4.7uF; C_0402; Voltage Rated 10V; Tolerance ±20%; Part CL05A475MP5NRNC; LCSC C23733
C427, C434: 2.2uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A225MQ5NSNC; LCSC C12530
FB401: FB_0603; Current Rating 200mA; Tolerance ±25%; Part GZ1608D601TF; LCSC C1002
LED300, LED301: FixLed307
R401: 1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1001TCE; LCSC C11702
R402, R403, R405: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R404, R406: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076
R407, R414, R415, R416: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
U403: STM32H562VGTx; LQFP-100_14x14mm_P0.5mm
X300: Q13FC1350000400; FC-135R_L3.2-W1.5; Frequency Tolerance ±20ppm; Part Q13FC13500004; LCSC C32346
Y400: ASE-xxxMHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN OT322512MJBA4SL; LCSC C725989

Connections:
+3V3: C400.1, C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C420.1, C421.1, C422.1, C425.1, C426.1, C432.1, FB401.2, R403.1, R405.1, R414.1, U403.6 (VBAT), U403.11 (VDD), U403.21 (VREF+), U403.28 (VDD), U403.50 (VDD), U403.73 (VDDUSB), U403.75 (VDD), U403.100 (VDD), Y400.1 (EN), Y400.4 (Vdd); also elsewhere on the board
/Backplane/GPIOL0: U403.79 (PC11); also elsewhere on the board
/Backplane/GPIOL1: U403.78 (PC10); also elsewhere on the board
/Backplane/GPIOL2: U403.69 (PA10); also elsewhere on the board
/Backplane/GPIOL3: U403.68 (PA9); also elsewhere on the board
/Backplane/GPIOL4: U403.67 (PA8); also elsewhere on the board
/Backplane/GPIOL5: U403.66 (PC9); also elsewhere on the board
/Backplane/GPIOL6: U403.65 (PC8); also elsewhere on the board
/Backplane/GPIOL7: U403.64 (PC7); also elsewhere on the board
/Backplane/GPIOL8: U403.63 (PC6); also elsewhere on the board
/Backplane/GPIOL9: U403.62 (PD15); also elsewhere on the board
/Backplane/GPIOL10: U403.61 (PD14); also elsewhere on the board
/Backplane/GPIOL11: U403.57 (PD10); also elsewhere on the board
/Backplane/GPIOL12: U403.56 (PD9); also elsewhere on the board
/Backplane/GPIOL13: U403.55 (PD8); also elsewhere on the board
/Backplane/GPIOL14: U403.54 (PB15); also elsewhere on the board
/Backplane/GPIOL15: U403.53 (PB14); also elsewhere on the board
/Backplane/GPIOR0: U403.46 (PE15); also elsewhere on the board
/Backplane/GPIOR1: U403.45 (PE14); also elsewhere on the board
/Backplane/GPIOR2: U403.44 (PE13); also elsewhere on the board
/Backplane/GPIOR3: U403.43 (PE12); also elsewhere on the board
/Backplane/GPIOR4: U403.42 (PE11); also elsewhere on the board
/Backplane/GPIOR5: U403.41 (PE10); also elsewhere on the board
/Backplane/GPIOR6: U403.40 (PE9); also elsewhere on the board
/Backplane/GPIOR7: U403.39 (PE8); also elsewhere on the board
/Backplane/GPIOR8: U403.38 (PE7); also elsewhere on the board
/Backplane/GPIOR9: U403.36 (PB1); also elsewhere on the board
/Backplane/GPIOR10: U403.35 (PB0); also elsewhere on the board
/Backplane/GPIOR11: U403.34 (PC5); also elsewhere on the board
/Backplane/GPIOR12: U403.33 (PC4); also elsewhere on the board
/Backplane/GPIOR13: U403.32 (PA7); also elsewhere on the board
/Backplane/GPIOR14: U403.31 (PA6); also elsewhere on the board
/Backplane/GPIOR15: U403.30 (PA5); also elsewhere on the board
/CAN transceiver 1/CAN.RX: U403.81 (PD0); also elsewhere on the board
/CAN transceiver 1/CAN.TX: U403.82 (PD1); also elsewhere on the board
/CAN transceiver 2/CAN.RX: U403.51 (PB12); also elsewhere on the board
/CAN transceiver 2/CAN.TX: U403.52 (PB13); also elsewhere on the board
/GPIO connector 0/input: U403.16 (PC1); also elsewhere on the board
/GPIO connector 0/output: U403.87 (PD6); also elsewhere on the board
/GPIO connector 1/input: U403.17 (PC2); also elsewhere on the board
/GPIO connector 1/output: U403.86 (PD5); also elsewhere on the board
/GPIO connector 2/input: U403.18 (PC3); also elsewhere on the board
/GPIO connector 2/output: U403.85 (PD4); also elsewhere on the board
/GPIO connector 3/input: U403.15 (PC0); also elsewhere on the board
/GPIO connector 3/output: U403.88 (PD7); also elsewhere on the board
/MCU/BOOT0: C410.1, R401.2, R402.1, U403.94 (BOOT0)
/MCU/BOOT_EN: R401.1, U403.93 (PB7)
/MCU/I2C1.SCL: U403.95 (PB8)
/MCU/I2C1.SDA: U403.96 (PB9)
/MCU/NRST: C415.1, R403.2, R404.1
/MCU/OSC32_IN: C314.1, U403.8 (PC14), X300.2
/MCU/OSC32_OUT: C313.1, U403.9 (PC15), X300.1
/MCU/OSC_IN: U403.12 (PH0), Y400.3 (OUT)
/MCU/QSPI1.CS: U403.47 (PB10); also elsewhere on the board
/MCU/QSPI1.IO0: U403.58 (PD11); also elsewhere on the board
/MCU/QSPI1.IO1: U403.59 (PD12); also elsewhere on the board
/MCU/QSPI1.IO2: U403.1 (PE2); also elsewhere on the board
/MCU/QSPI1.IO3: U403.60 (PD13); also elsewhere on the board
/MCU/QSPI1.SCLK: U403.37 (PB2); also elsewhere on the board
/MCU/STATUS_LED: R415.1, U403.4 (PE5)
/MCU/SWD.SWCLK: U403.76 (PA14(JTCK); also elsewhere on the board
/MCU/SWD.SWDIO: U403.72 (PA13(JTMS); also elsewhere on the board
/MCU/SWD.~RST: BTN400.3, R404.2, U403.14 (NRST); also elsewhere on the board
/MCU/USB_MCU.D+: U403.71 (PA12); also elsewhere on the board
/MCU/USB_MCU.D-: U403.70 (PA11); also elsewhere on the board
/MCU/USER_LED_1: R416.1, U403.2 (PE3)
/MCU/USER_LED_2: R407.1, U403.3 (PE4)
/MCU/USR_BTN: C416.1, R405.2, R406.1
/MCU/USR_BUTTON: BTN400.4, R406.2, U403.5 (PE6)
/MCU/VCAP_1: C427.1, U403.48 (VCAP)
/MCU/VCAP_2: C434.1, U403.98 (VCAP)
/MCU/VDDA: C423.1, C424.1, FB401.1, U403.22 (VDDA)
GND: BTN400.1, BTN400.2, C313.2, C314.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C410.2, C415.2, C416.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C432.2, C434.2, LED300.2, LED300.4, LED301.2, LED301.4, R402.2, U403.10 (VSS), U403.19 (VSSA), U403.20 (VREF-), U403.27 (VSS), U403.49 (VSS), U403.74 (VSS), U403.99 (VSS), Y400.2 (GND); also elsewhere on the board
unnamed: LED300.1, R416.2
unnamed: LED300.3, R407.2
unnamed: LED301.1, R415.2
unnamed: LED301.3, R414.2

Notes on the sheet:
Boot EN can be pulled up with BOOT_EN pin C412 will retain voltage on boot0 pin during MCU reboot routine
RESET BUTTON
CAN
CRYSTAL RESONATORS
POWER INDICATOR AND USER LEDs
NOTICE:
Target I_{LED} = 5mA
Design choice due: es0565, sec 2.2.3
AVDD
BACKPLANE GPIO
BULK
USER BUTTON
NOTE: PLACE CAPACTITOR AT PWR PIN

Parts:
C900: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C902: 10uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A106MQ5NUNC; LCSC C15525
C904: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
D301: Red; D_0603; Part KT-0603R; LCSC C2286
R308: 1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1001TCE; LCSC C11702
R900, R901, R902, R903: 22Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF220JTCE; LCSC C25092
U302: CH334P; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
Y900: 12Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C904.1, D301.2, U302.15 (5V); also elsewhere on the board
/MCU/USB_MCU.D+: R901.1; also elsewhere on the board
/MCU/USB_MCU.D-: R900.1; also elsewhere on the board
/ST-LINK/ST-LINK.D+: R903.1; also elsewhere on the board
/ST-LINK/ST-LINK.D-: R902.1; also elsewhere on the board
/USB-hub/USBIN1.D+: U302.12 (DPU); also elsewhere on the board
/USB-hub/USBIN1.D-: U302.11 (DMU); also elsewhere on the board
/USB-hub/USBOUT1_R.D+: R903.2, U302.4 (DP4)
/USB-hub/USBOUT1_R.D-: R902.2, U302.3 (DM4)
/USB-hub/USB_MCU_R.D+: R901.2, U302.6 (DP3)
/USB-hub/USB_MCU_R.D-: R900.2, U302.5 (DM3)
GND: C900.2, C902.2, C904.2, U302.17 (GND), Y900.2, Y900.4; also elsewhere on the board
unnamed: D301.1, R308.2
unnamed: C900.1, C902.1, U302.16 (3V3)
unnamed: R308.1, U302.14 (PGANG)
unnamed: U302.2 (XI), Y900.3
unnamed: U302.1 (XO), Y900.1

Notes on the sheet:
USB HUB TO MCU AND STLINK

Parts:
C100: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
U100: W25Q128; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; Part W25Q128JVSIQ; LCSC C97521

Connections:
+3V3: C100.1, U100.8 (VCC); also elsewhere on the board
/MCU/QSPI1.CS: U100.1 (CS#); also elsewhere on the board
/MCU/QSPI1.IO0: U100.5 (DI); also elsewhere on the board
/MCU/QSPI1.IO1: U100.2 (DO); also elsewhere on the board
/MCU/QSPI1.IO2: U100.3 (IO2); also elsewhere on the board
/MCU/QSPI1.IO3: U100.7 (IO3); also elsewhere on the board
/MCU/QSPI1.SCLK: U100.6 (CLK); also elsewhere on the board
GND: C100.2, U100.4 (GND); also elsewhere on the board
